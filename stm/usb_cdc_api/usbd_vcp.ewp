# IAR project usbd_vcp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; STM32F40XX; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\patches; ..\..\common; ..\lib\STM32_USB_Device_Library\Core\inc; ..\lib\STM32_USB_Device_Library\Class\cdc\inc; ..\lib\STM32_USB_OTG_Driver\inc; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\lib\CMSIS\Include; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_msc.srec
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../common/: api.c api_buf.c api_str_buf.c api_str_seq.c
    ./: app.c stm32fxxx_it.c system_stm32f4xx.c usb_api.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../lib/CMSIS/Source/Templates/iar/: startup_stm32f40xx.s
    ../lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../patches/: usbd_cdc_core.c
    ../lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
