# IAR project usb_dev_serial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $_TIVA_WARE_$; ../../common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_serial.bin
  ILINK.IlinkOutputFile: usb_dev_serial.out
  ILINK.IlinkIcfFile: usb_dev_serial.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    $_TIVA_WARE_$/driverlib/ewarm/Exe/: driverlib.a
    $_TIVA_WARE_$/usblib/ewarm/Exe/: usblib.a
  group Source
    ../../common/: api.c api_buf.c api_str_buf.c api_str_seq.c
    ./: main.c startup_ewarm.c usb_api.c usb_dev_serial.c usb_serial_structs.c
    $_TIVA_WARE_$/utils/: uartstdio.c ustdlib.c
    ../patches/: usbbuffer.c usbdcdc.c
